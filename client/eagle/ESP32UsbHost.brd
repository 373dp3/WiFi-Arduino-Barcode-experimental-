# Repository 373dp3/WiFi-Arduino-Barcode-experimental-

## EAGLE design client/eagle/ESP32UsbHost.brd

Parts:
C1, C8, C12: 4u7; C0603
C5: 0.01u; C0603
C7: 1u; C0603
C9: C-05254_MICRO_USB
C11, C13: 0.1u; C0603
C14, C15: 47p; C0603
IC1: I-12635_ADP3338AKCZ; SOT223
IC2: NJM2884; SOT89-5
IC3: FT231X_I06713; SSOP20(2)
IC4: ESP-WROOM-02; FRONT-FACE_HANDSOLDER
L2: BLM21PG331; L2012C
LCD1: LCD_2X16CONN_ONLY; HY-1602F_2
R1, R5, R6, R7, R8, R9, R10, R11, R12, R15: 10k; R0603
R2: 10; R0603
R3, R4: 27R; R0603
R13: 2k; R0603
R14: 1k; R0603
SV1: MA03-1
T1, T2, T4: BC808-NPN-SOT23-BEC; SOT23-BEC
U2: USB_HOST_MINI
VR1: P-04305_PVZ3_VR_POTENTION_METER; VR_POTENTION_METER

Connections:
+3V3: C1.1, C8.1, IC1.2 (OUT), IC1.4, IC2.4 (OUT), IC3.3 (VCCIO), IC4.1 (3V3), LCD1.2 (VCC), LCD1.15 (LEDA), R5.1, R10.1, R11.1, R12.1, R15.1, U2.3V3
BEEP: IC4.10 (IO4), R1.1, T4.B
CONT: LCD1.3 (VO), R13.1, VR1.2
DB4: LCD1.11 (DB4), U2.GO4
DB5: LCD1.12 (DB5), U2.GO5
DB6: LCD1.13 (DB6), U2.GO6
DB7: LCD1.14 (DB7), U2.GO7
DTR: IC3.1 (!DTR), R7.2, T2.E
EN: U2.RST2 (RST)
FT_3V3: C13.1, IC3.13 (3V3OUT), IC3.14 (!RESET)
GND: C1.2, C5.2, C7.2, C8.2, C9.5, C11.2, C12.2, C13.2, C14.2, C15.2, IC1.1 (GND), IC2.2 (GND), IC3.6 (GND), IC3.16 (GND), IC4.9 (GND1), IC4.13 (GND2), IC4.18 (GND3), LCD1.1 (VSS), LCD1.5 (R/W), R1.2, R2.1, R6.1, R13.2, T4.E, U2.GND (GND1), U2.GND2, VR1.3
INT: IC4.7 (IO2), R5.2, U2.9 (D9_INT)
IO0: IC4.8 (IO0), R11.2, T2.C
IO16: IC4.17 (IO16)
MISO: IC4.4 (IO12), U2.12 (MISO)
MOSI: IC4.5 (IO13), U2.11 (MOSI)
unnamed: IC4.6 (IO15), R6.2
unnamed: LCD1.6 (E), U2.GO3
unnamed: LCD1.4 (RS), U2.GO2
unnamed: LCD1.16 (LEDK), R2.2
unnamed: IC3.12 (USBDM), R4.1
unnamed: IC3.11 (USBDP), R3.2
unnamed: IC4.2 (EN), R10.2
unnamed: R14.1, SV1.3, T4.C
unnamed: R15.2, U2.MAX_RESET (MRESET)
unnamed: R7.1, T1.B
unnamed: C5.1, C9.1, L2.1
unnamed: R8.1, T2.B
unnamed: IC2.1 (CTRL), R9.1
RST: IC4.15 (RST), R12.2, T1.C
RTS: IC3.2 (!RTS), R8.2, T1.E
RX0: IC3.20 (TXD), IC4.11 (RXD)
SCK: IC4.3 (IO14), U2.13 (SCK)
SS: IC4.14 (IO5), U2.10 (D10_SS)
TOUT: IC4.16 (TOUT)
TX0: IC3.4 (RXD), IC4.12 (TXD)
USBDM: C9.2, C15.1, R4.2
USBDP: C9.3, C14.1, R3.1
VCC: C7.1, C11.1, C12.1, IC1.3 (IN), IC2.5 (IN), IC3.15 (VCC), L2.2, R9.2, R14.2, SV1.1, U2.VBUS

Notes on the sheet:
コンデンサはNJM2884と共用 出力に1uF以上。温度安定性を考えれば、NJM2884と同じく4u7。
IO5がSS、IO2がINT
P-04305 4.7kΩ SMDトリマポテンショメータ

Board: 2 copper layers, 49.9 x 39.9 mm, 37 parts (2 on the bottom side), 36 nets.

## Commit log

2018-09-03 初期コミット
2018-09-03 起動関連
2018-09-03 README.mdの追加
2018-09-03 画像更新
2018-09-03 Revert "README.mdの追加"
    This reverts commit 0cf8ce130d72440b3f90f2d23c22faa8c3d970d5.
2018-09-03 README.mdの更新
2018-09-03 WiFiバーコード設定ツールの追加
2018-09-03 実行用バイナリの追加
